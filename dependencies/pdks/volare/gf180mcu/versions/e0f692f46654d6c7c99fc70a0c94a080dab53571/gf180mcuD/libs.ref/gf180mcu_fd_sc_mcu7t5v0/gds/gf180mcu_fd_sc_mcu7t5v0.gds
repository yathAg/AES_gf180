* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__oai33_1 A1 A2 A3 B1 B2 B3 VDD VNW VSS ZN
XM1 n1 B3 VSS VSUBS nfet_05v0 w=0.82u l=0.6u
XM2 VSS B2 n1 VSUBS nfet_05v0 w=0.82u l=0.6u
XM3 n1 B1 VSS VSUBS nfet_05v0 w=0.82u l=0.6u
XM4 ZN A1 n1 VSUBS nfet_05v0 w=0.82u l=0.6u
XM5 n1 A2 ZN VSUBS nfet_05v0 w=0.82u l=0.6u
XM6 ZN A3 n1 VSUBS nfet_05v0 w=0.82u l=0.6u
XM7 n2 B3 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM8 n3 B2 n2 VNW pfet_05v0 w=1.095u l=0.5u
XM9 ZN B1 n3 VNW pfet_05v0 w=1.095u l=0.5u
XM10 n4 A1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM11 n5 A2 n4 VNW pfet_05v0 w=1.095u l=0.5u
XM12 VDD A3 n5 VNW pfet_05v0 w=1.095u l=0.5u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__oai33_1')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,8.4,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76),(-0.43,4.35),(8.83,4.35),(8.83,1.76),(5.695,1.76),(5.695,1.885),(4.41,1.885),(4.41,1.76)])
R(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,2.485,7.6,3.58)])
P(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,0.34),(0.18,1.16),(4.88,1.16),(4.88,1.285),(5.24,1.285),(5.24,1.16),(7.7,1.16),(7.7,0.34)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.12),(0.62,3.8),(1.12,3.8),(1.12,2.01),(1.22,2.01),(1.22,0.12)],
  [(1.74,0.12),(1.74,3.8),(2.24,3.8),(2.24,2.01),(2.34,2.01),(2.34,0.12)],
  [(2.86,0.12),(2.86,3.8),(3.36,3.8),(3.36,2.01),(3.46,2.01),(3.46,0.12)],
  [(3.98,0.12),(3.98,3.8),(4.48,3.8),(4.48,2.01),(4.58,2.01),(4.58,0.12)],
  [(5.54,0.12),(5.54,2.01),(5.64,2.01),(5.64,3.8),(6.14,3.8),(6.14,0.12)],
  [(6.66,0.12),(6.66,3.8),(7.16,3.8),(7.16,2.01),(7.26,2.01),(7.26,0.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76,8.6,4.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2,8.6,1.76)])
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 0.73, 1.69, 0.22, 0.22, 4, 1, 1.12, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(0.25,0.535,0.47,0.755), (2.49,0.535,2.71,0.755), (3.61,0.535,3.83,0.755), (6.29,0.535,6.51,0.755), (1.37,0.59,1.59,0.81), (7.41,0.765,7.63,0.985), (4.95,0.995,5.17,1.215), (5.74,1.85,5.96,2.07), (6.77,1.85,6.99,2.07), (0.25,2.63,0.47,2.85), (3.56,2.63,3.78,2.85), (7.31,2.63,7.53,2.85), (0.25,3.1,0.47,3.32), (3.56,3.1,3.78,3.32), (7.31,3.1,7.53,3.32)])
A(gf180mcu_fd_sc_mcu7t5v0_, metal1, 1.8, 1.525, 0.32, 1.795, 3, 1, 1.12, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(0.705,1.525,1,3.32)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(5.16,1.77),(5.16,3.32),(5.48,3.32),(5.48,2.14),(6.04,2.14),(6.04,1.77)],
  [(1.365,0.53),(1.365,1.275),(3.175,1.275),(3.175,0.76),(6.57,0.76),(6.57,0.53),(2.945,0.53),(2.945,1.045),(1.595,1.045),(1.595,0.53)],
  [(7.405,0.555),(7.405,0.99),(3.49,0.99),(3.49,3.38),(3.79,3.38),(3.79,1.22),(7.635,1.22),(7.635,0.555)],
  [(6.28,1.77),(6.28,3.32),(6.6,3.32),(6.6,2.14),(7.87,2.14),(7.87,1.77)],
  [(0,-0.3),(0,0.3),(0.245,0.3),(0.245,0.815),(0.475,0.815),(0.475,0.3),(2.485,0.3),(2.485,0.815),(2.715,0.815),(2.715,0.3),(8.4,0.3),(8.4,-0.3)],
  [(0.245,2.53),(0.245,3.62),(0,3.62),(0,4.22),(8.4,4.22),(8.4,3.62),(7.535,3.62),(7.535,2.53),(7.305,2.53),(7.305,3.62),(0.475,3.62),(0.475,2.53)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,8.68,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,8.4,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43,8.83,1.76)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A3', (7,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B1', (3.08,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B2', (1.96,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B3', (0.84,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (3.92,3.92), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (3.92,0), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('ZN', (3.64,1.4), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A1', (4.2,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A2', (5.32,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__oai33_1.gds')

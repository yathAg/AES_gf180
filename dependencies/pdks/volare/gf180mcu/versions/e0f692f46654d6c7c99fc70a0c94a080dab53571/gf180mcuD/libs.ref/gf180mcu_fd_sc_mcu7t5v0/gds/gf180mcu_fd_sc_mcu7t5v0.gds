* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__oai32_4 A1 A2 A3 B1 B2 VDD VNW VSS ZN
XM1 VSS A2 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM2 n1 A3 VSS VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM3 VSS A1 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM4 ZN B2 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM5 n1 B1 ZN VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM6 n2 A2 n3 VNW pfet_05v0 w=1.095u l=0.5u
XM7 VDD A3 n2 VNW pfet_05v0 w=1.095u l=0.5u
XM8 n4 A3 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM9 n3 A2 n4 VNW pfet_05v0 w=1.095u l=0.5u
XM10 n5 A2 n3 VNW pfet_05v0 w=1.095u l=0.5u
XM11 VDD A3 n5 VNW pfet_05v0 w=1.095u l=0.5u
XM12 n6 A3 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM13 n7 A2 n6 VNW pfet_05v0 w=1.095u l=0.5u
XM14 ZN A1 n7 VNW pfet_05v0 w=1.095u l=0.5u
XM15 n3 A1 ZN VNW pfet_05v0 w=1.095u l=0.5u m=3
XM16 n8 B2 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM17 ZN B1 n8 VNW pfet_05v0 w=1.095u l=0.5u
XM18 n9 B1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM19 VDD B2 n9 VNW pfet_05v0 w=1.095u l=0.5u
XM20 n10 B2 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM21 ZN B1 n10 VNW pfet_05v0 w=1.095u l=0.5u
XM22 n11 B1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM23 VDD B2 n11 VNW pfet_05v0 w=1.095u l=0.5u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__oai32_4')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,24.08,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76),(-0.43,4.35),(24.51,4.35),(24.51,1.76),(22.98,1.76),(22.98,1.885),(13.825,1.885),(13.825,1.76)])
R(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.435,2.485,14.085,3.58), (14.445,2.485,23.795,3.58)])
P(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.385,0.34),(0.385,1.16),(14.285,1.16),(14.285,1.285),(22.545,1.285),(22.545,1.16),(23.885,1.16),(23.885,0.34),(22.445,0.34),(22.445,0.465),(14.385,0.465),(14.385,0.34)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.825,0.12),(0.825,2.01),(0.925,2.01),(0.925,3.8),(1.425,3.8),(1.425,0.12)],
  [(1.945,0.12),(1.945,2.01),(2.045,2.01),(2.045,3.8),(2.545,3.8),(2.545,1.97),(3.065,1.97),(3.065,3.8),(3.565,3.8),(3.565,2.01),(3.665,2.01),(3.665,0.12),(3.065,0.12),(3.065,1.74),(2.545,1.74),(2.545,0.12)],
  [(4.185,0.12),(4.185,2.01),(4.285,2.01),(4.285,3.8),(4.785,3.8),(4.785,1.97),(5.305,1.97),(5.305,3.8),(5.805,3.8),(5.805,2.01),(5.905,2.01),(5.905,0.12),(5.305,0.12),(5.305,1.74),(4.785,1.74),(4.785,0.12)],
  [(6.425,0.12),(6.425,2.01),(6.525,2.01),(6.525,3.8),(7.025,3.8),(7.025,1.97),(7.545,1.97),(7.545,3.8),(8.045,3.8),(8.045,2.01),(8.145,2.01),(8.145,0.12),(7.545,0.12),(7.545,1.74),(7.025,1.74),(7.025,0.12)],
  [(8.665,0.12),(8.665,2.01),(8.765,2.01),(8.765,3.8),(9.265,3.8),(9.265,0.12)],
  [(9.785,0.12),(9.785,2.01),(9.885,2.01),(9.885,3.8),(10.385,3.8),(10.385,2.01),(10.905,2.01),(10.905,3.8),(11.405,3.8),(11.405,2.01),(12.125,2.01),(12.125,3.8),(12.625,3.8),(12.625,2.01),(13.145,2.01),(13.145,3.8),(13.645,3.8),(13.645,2.01),(13.745,2.01),(13.745,0.12),(13.145,0.12),(13.145,1.74),(12.625,1.74),(12.625,0.12),(12.025,0.12),(12.025,1.74),(11.505,1.74),(11.505,0.12),(10.905,0.12),(10.905,1.74),(10.385,1.74),(10.385,0.12)],
  [(14.785,0.12),(14.785,2.01),(14.885,2.01),(14.885,3.8),(15.385,3.8),(15.385,0.12)],
  [(15.905,0.12),(15.905,2.01),(16.005,2.01),(16.005,3.8),(16.505,3.8),(16.505,1.97),(17.025,1.97),(17.025,3.8),(17.525,3.8),(17.525,2.01),(17.625,2.01),(17.625,0.12),(17.025,0.12),(17.025,1.74),(16.505,1.74),(16.505,0.12)],
  [(18.145,0.12),(18.145,2.01),(18.245,2.01),(18.245,3.8),(18.745,3.8),(18.745,1.97),(19.265,1.97),(19.265,3.8),(19.765,3.8),(19.765,2.01),(19.865,2.01),(19.865,0.12),(19.265,0.12),(19.265,1.74),(18.745,1.74),(18.745,0.12)],
  [(20.385,0.12),(20.385,2.01),(20.485,2.01),(20.485,3.8),(20.985,3.8),(20.985,1.97),(21.505,1.97),(21.505,3.8),(22.005,3.8),(22.005,2.01),(22.105,2.01),(22.105,0.12),(21.505,0.12),(21.505,1.74),(20.985,1.74),(20.985,0.12)],
  [(22.845,0.12),(22.845,3.8),(23.345,3.8),(23.345,2.01),(23.445,2.01),(23.445,0.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76,24.28,4.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2,24.28,1.76)])
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 1.575, 0.41, 0.22, 0.22, 6, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 16.655, 0.535, 0.22, 0.22, 3, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 0.455, 0.87, 0.22, 0.22, 6, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 15.535, 0.995, 0.22, 0.22, 4, 1, 2.24, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(13.895,0.535,14.115,0.755), (23.595,0.535,23.815,0.755), (1.065,1.85,1.285,2.07), (2.185,1.85,2.405,2.07), (3.205,1.85,3.425,2.07), (4.425,1.85,4.645,2.07), (5.445,1.85,5.665,2.07), (6.665,1.85,6.885,2.07), (7.685,1.85,7.905,2.07), (8.905,1.85,9.125,2.07), (10.025,1.85,10.245,2.07), (11.045,1.85,11.265,2.07), (12.265,1.85,12.485,2.07), (13.285,1.85,13.505,2.07), (15.025,1.85,15.245,2.07), (16.145,1.85,16.365,2.07), (17.165,1.85,17.385,2.07), (20.625,1.85,20.845,2.07), (21.645,1.85,21.865,2.07), (22.985,1.85,23.205,2.07), (18.385,1.94,18.605,2.16), (19.405,1.94,19.625,2.16), (10.535,2.585,10.755,2.805), (12.775,2.585,12.995,2.805), (0.505,2.63,0.725,2.85), (23.505,2.63,23.725,2.85), (4.935,2.945,5.155,3.165), (16.655,2.97,16.875,3.19), (21.135,2.97,21.355,3.19), (0.505,3.1,0.725,3.32), (23.505,3.1,23.725,3.32), (11.655,3.145,11.875,3.365), (13.795,3.145,14.015,3.365), (2.695,3.29,2.915,3.51), (7.175,3.29,7.395,3.51), (14.515,3.29,14.735,3.51), (18.895,3.29,19.115,3.51)])
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(9.57,1.8,13.88,2.12)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(3.64,1.345),(3.64,1.8),(1.73,1.8),(1.73,2.12),(3.87,2.12),(3.87,1.575),(6.21,1.575),(6.21,2.12),(8.35,2.12),(8.35,1.8),(6.44,1.8),(6.44,1.345)],
  [(1.055,1.76),(1.055,2.58),(3.73,2.58),(3.73,2.69),(6.365,2.69),(6.365,2.58),(9.135,2.58),(9.135,1.76),(8.895,1.76),(8.895,2.35),(5.725,2.35),(5.725,1.825),(4.365,1.825),(4.365,2.35),(1.295,2.35),(1.295,1.76)],
  [(0.5,2.53),(0.5,3.38),(0.73,3.38),(0.73,3.055),(3.23,3.055),(3.23,3.17),(6.865,3.17),(6.865,3.055),(8.19,3.055),(8.19,3.37),(14.085,3.37),(14.085,3.14),(8.42,3.14),(8.42,2.825),(6.615,2.825),(6.615,2.94),(3.48,2.94),(3.48,2.825),(0.73,2.825),(0.73,2.53)],
  [(17.64,1.45),(17.64,1.8),(16.005,1.8),(16.005,2.12),(17.87,2.12),(17.87,1.68),(20.21,1.68),(20.21,2.12),(22.35,2.12),(22.35,1.8),(20.44,1.8),(20.44,1.45)],
  [(14.12,0.99),(14.12,2.36),(9.57,2.36),(9.57,2.815),(15.045,2.815),(15.045,3.24),(18.585,3.24),(18.585,3.055),(19.425,3.055),(19.425,3.24),(21.81,3.24),(21.81,2.92),(19.655,2.92),(19.655,2.825),(18.335,2.825),(18.335,2.92),(15.295,2.92),(15.295,2.36),(14.42,2.36),(14.42,1.22),(22.535,1.22),(22.535,0.99)],
  [(22.965,1.76),(22.965,2.36),(19.685,2.36),(19.685,1.91),(18.325,1.91),(18.325,2.36),(15.775,2.36),(15.775,1.8),(14.65,1.8),(14.65,2.12),(15.545,2.12),(15.545,2.68),(18.05,2.68),(18.05,2.595),(19.945,2.595),(19.945,2.68),(23.225,2.68),(23.225,1.76)],
  [(13.405,0.53),(13.405,0.865),(0.385,0.865),(0.385,1.095),(13.635,1.095),(13.635,0.76),(23.885,0.76),(23.885,0.53)],
  [(0,-0.3),(0,0.3),(1.515,0.3),(1.515,0.635),(1.855,0.635),(1.855,0.3),(3.755,0.3),(3.755,0.635),(4.095,0.635),(4.095,0.3),(5.995,0.3),(5.995,0.635),(6.335,0.635),(6.335,0.3),(8.235,0.3),(8.235,0.635),(8.575,0.635),(8.575,0.3),(10.475,0.3),(10.475,0.635),(10.815,0.635),(10.815,0.3),(12.715,0.3),(12.715,0.635),(13.055,0.635),(13.055,0.3),(24.08,0.3),(24.08,-0.3)],
  [(23.5,2.53),(23.5,3.62),(19.175,3.62),(19.175,3.285),(18.835,3.285),(18.835,3.62),(14.795,3.62),(14.795,3.285),(14.455,3.285),(14.455,3.62),(7.455,3.62),(7.455,3.285),(7.115,3.285),(7.115,3.62),(2.975,3.62),(2.975,3.285),(2.635,3.285),(2.635,3.62),(0,3.62),(0,4.22),(24.08,4.22),(24.08,3.62),(23.73,3.62),(23.73,2.53)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,24.36,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,24.08,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43,24.51,1.76)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A3', (3.64,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B1', (20.44,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B2', (17.64,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (12.04,3.92), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (12.04,0), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('ZN', (17.08,3.08), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A1', (11.48,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A2', (5.32,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__oai32_4.gds')

* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__oai211_4 A1 A2 B C VDD VNW VSS ZN
XM1 ZN A2 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM2 n1 A1 ZN VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM3 n2 B n1 VSUBS nfet_05v0 w=0.82u l=0.6u
XM4 VSS C n2 VSUBS nfet_05v0 w=0.82u l=0.6u
XM5 n3 C VSS VSUBS nfet_05v0 w=0.82u l=0.6u
XM6 n1 B n3 VSUBS nfet_05v0 w=0.82u l=0.6u
XM7 n4 B n1 VSUBS nfet_05v0 w=0.82u l=0.6u
XM8 VSS C n4 VSUBS nfet_05v0 w=0.82u l=0.6u
XM9 n5 C VSS VSUBS nfet_05v0 w=0.82u l=0.6u
XM10 n1 B n5 VSUBS nfet_05v0 w=0.82u l=0.6u
XM11 n6 A2 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM12 ZN A1 n6 VNW pfet_05v0 w=1.095u l=0.5u
XM13 n7 A1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM14 VDD A2 n7 VNW pfet_05v0 w=1.095u l=0.5u
XM15 n8 A2 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM16 ZN A1 n8 VNW pfet_05v0 w=1.095u l=0.5u
XM17 n9 A1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM18 VDD A2 n9 VNW pfet_05v0 w=1.095u l=0.5u
XM19 ZN B VDD VNW pfet_05v0 w=0.985u l=0.5u m=4
XM20 VDD C ZN VNW pfet_05v0 w=0.985u l=0.5u m=4
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__oai211_4')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,18.48,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76),(-0.43,4.35),(18.91,4.35),(18.91,1.76),(8.995,1.76),(8.995,1.885),(1.135,1.885),(1.135,1.76)])
P(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,0.34),(0.18,1.16),(1.52,1.16),(1.52,1.285),(8.6,1.285),(8.6,1.16),(18.2,1.16),(18.2,0.34),(8.5,0.34),(8.5,0.465),(1.62,0.465),(1.62,0.34)],
  [(0.28,2.485),(0.28,3.58),(18.2,3.58),(18.2,2.595),(9.8,2.595),(9.8,2.485)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.12),(0.62,2.005),(0.72,2.005),(0.72,3.8),(1.22,3.8),(1.22,0.12)],
  [(1.96,0.12),(1.96,2.005),(2.06,2.005),(2.06,3.8),(2.56,3.8),(2.56,2.005),(3.08,2.005),(3.08,3.8),(3.58,3.8),(3.58,2.005),(3.68,2.005),(3.68,0.12),(3.08,0.12),(3.08,1.72),(2.56,1.72),(2.56,0.12)],
  [(4.2,0.12),(4.2,2.005),(4.3,2.005),(4.3,3.8),(4.8,3.8),(4.8,2.005),(5.32,2.005),(5.32,3.8),(5.82,3.8),(5.82,2.005),(5.92,2.005),(5.92,0.12),(5.32,0.12),(5.32,1.72),(4.8,1.72),(4.8,0.12)],
  [(6.44,0.12),(6.44,2.005),(6.54,2.005),(6.54,3.8),(7.04,3.8),(7.04,2.005),(7.56,2.005),(7.56,3.8),(8.06,3.8),(8.06,2.005),(8.16,2.005),(8.16,0.12),(7.56,0.12),(7.56,1.72),(7.04,1.72),(7.04,0.12)],
  [(8.9,0.12),(8.9,3.8),(9.4,3.8),(9.4,2.005),(9.5,2.005),(9.5,0.12)],
  [(10.02,0.12),(10.02,2.005),(10.12,2.005),(10.12,3.8),(10.62,3.8),(10.62,0.12)],
  [(11.04,0.12),(11.04,2.005),(11.14,2.005),(11.14,3.8),(11.64,3.8),(11.64,2.005),(12.16,2.005),(12.16,3.8),(12.66,3.8),(12.66,2.005),(12.76,2.005),(12.76,0.12),(12.16,0.12),(12.16,1.72),(11.64,1.72),(11.64,0.12)],
  [(13.08,0.12),(13.08,2.005),(13.18,2.005),(13.18,3.8),(13.68,3.8),(13.68,2.005),(14.2,2.005),(14.2,3.8),(14.7,3.8),(14.7,2.005),(14.8,2.005),(14.8,0.12),(14.2,0.12),(14.2,1.72),(13.68,1.72),(13.68,0.12)],
  [(15.12,0.12),(15.12,2.005),(15.22,2.005),(15.22,3.8),(15.72,3.8),(15.72,2.005),(16.24,2.005),(16.24,3.8),(16.74,3.8),(16.74,2.005),(16.84,2.005),(16.84,0.12),(16.24,0.12),(16.24,1.72),(15.72,1.72),(15.72,0.12)],
  [(17.16,0.12),(17.16,2.005),(17.26,2.005),(17.26,3.8),(17.76,3.8),(17.76,0.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76,18.68,4.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2,18.68,1.76)])
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 2.71, 0.535, 0.22, 0.22, 3, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 1.59, 0.995, 0.22, 0.22, 4, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 10.77, 2.97, 0.22, 0.22, 4, 1, 2.04, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 11.79, 3.29, 0.22, 0.22, 3, 1, 2.04, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(11.79,0.41,12.01,0.63), (15.87,0.41,16.09,0.63), (0.25,0.535,0.47,0.755), (9.65,0.535,9.87,0.755), (13.83,0.535,14.05,0.755), (17.91,0.87,18.13,1.09), (13.27,1.33,13.49,1.55), (14.39,1.33,14.61,1.55), (17.33,1.33,17.55,1.55), (2.15,1.455,2.37,1.675), (3.27,1.455,3.49,1.675), (6.68,1.84,6.9,2.06), (7.7,1.84,7.92,2.06), (9.05,1.84,9.27,2.06), (10.255,1.84,10.475,2.06), (11.28,1.84,11.5,2.06), (12.3,1.84,12.52,2.06), (15.36,1.84,15.58,2.06), (16.38,1.84,16.6,2.06), (0.86,1.915,1.08,2.135), (4.44,1.915,4.66,2.135), (5.46,1.915,5.68,2.135), (0.35,2.63,0.57,2.85), (2.71,2.63,2.93,2.85), (17.91,2.665,18.13,2.885), (7.19,2.97,7.41,3.19), (0.35,3.1,0.57,3.32), (2.71,3.1,2.93,3.32), (17.91,3.135,18.13,3.355), (4.95,3.29,5.17,3.51), (9.65,3.29,9.87,3.51)])
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(10.75,1.8,16.84,2.12)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(1.96,1.45),(1.96,1.68),(6.54,1.68),(6.54,2.12),(8.31,2.12),(8.31,1.77),(6.79,1.77),(6.79,1.45)],
  [(8.54,1.77),(8.54,2.36),(6.205,2.36),(6.205,1.91),(0.62,1.91),(0.62,2.14),(5.955,2.14),(5.955,2.68),(8.88,2.68),(8.88,2.12),(9.41,2.12),(9.41,1.77)],
  [(1.52,0.99),(1.52,1.22),(9.64,1.22),(9.64,2.795),(9.09,2.795),(9.09,2.92),(5.725,2.92),(5.725,2.795),(4.39,2.795),(4.39,2.92),(2.99,2.92),(2.99,2.475),(2.65,2.475),(2.65,3.325),(2.99,3.325),(2.99,3.24),(4.64,3.24),(4.64,3.025),(5.475,3.025),(5.475,3.24),(9.34,3.24),(9.34,3.025),(10.175,3.025),(10.175,3.24),(11.48,3.24),(11.48,3.055),(12.32,3.055),(12.32,3.24),(13.52,3.24),(13.52,3.055),(14.36,3.055),(14.36,3.24),(15.56,3.24),(15.56,3.055),(16.4,3.055),(16.4,3.24),(17.45,3.24),(17.45,2.795),(9.96,2.795),(9.96,0.99)],
  [(12.93,1.22),(12.93,1.325),(10.2,1.325),(10.2,2.425),(10.52,2.425),(10.52,1.555),(17.76,1.555),(17.76,1.325),(15.08,1.325),(15.08,1.22)],
  [(0.18,0.53),(0.18,0.76),(10.655,0.76),(10.655,1.095),(12.55,1.095),(12.55,0.76),(15.33,0.76),(15.33,1.095),(18.2,1.095),(18.2,0.865),(15.56,0.865),(15.56,0.53),(12.32,0.53),(12.32,0.865),(10.885,0.865),(10.885,0.53)],
  [(0,-0.3),(0,0.3),(11.73,0.3),(11.73,0.635),(12.07,0.635),(12.07,0.3),(15.81,0.3),(15.81,0.635),(16.15,0.635),(16.15,0.3),(18.48,0.3),(18.48,-0.3)],
  [(0.345,2.53),(0.345,3.62),(0,3.62),(0,4.22),(18.48,4.22),(18.48,3.62),(18.135,3.62),(18.135,2.595),(17.905,2.595),(17.905,3.62),(16.15,3.62),(16.15,3.285),(15.81,3.285),(15.81,3.62),(14.11,3.62),(14.11,3.285),(13.77,3.285),(13.77,3.62),(12.07,3.62),(12.07,3.285),(11.73,3.285),(11.73,3.62),(9.93,3.62),(9.93,3.285),(9.59,3.285),(9.59,3.62),(5.23,3.62),(5.23,3.285),(4.89,3.285),(4.89,3.62),(0.575,3.62),(0.575,2.53)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,18.76,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,18.48,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43,18.91,1.76)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B', (13.16,1.4), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('C', (13.72,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (9.4,3.92), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (9.4,0), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('ZN', (8.68,3.08), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A1', (7,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A2', (6.44,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__oai211_4.gds')

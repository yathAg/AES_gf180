* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__oai33_2 A1 A2 A3 B1 B2 B3 VDD VNW VSS ZN
XM1 VSS B3 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM2 n1 B2 VSS VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM3 VSS B1 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM4 ZN A3 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM5 n1 A2 ZN VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM6 ZN A1 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM7 n2 B3 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM8 n3 B2 n2 VNW pfet_05v0 w=1.095u l=0.5u
XM9 ZN B1 n3 VNW pfet_05v0 w=1.095u l=0.5u
XM10 n4 B1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM11 n5 B2 n4 VNW pfet_05v0 w=1.095u l=0.5u
XM12 VDD B3 n5 VNW pfet_05v0 w=1.095u l=0.5u
XM13 n6 A3 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM14 n7 A2 n6 VNW pfet_05v0 w=1.095u l=0.5u
XM15 ZN A1 n7 VNW pfet_05v0 w=1.095u l=0.5u
XM16 n8 A1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM17 n9 A2 n8 VNW pfet_05v0 w=1.095u l=0.5u
XM18 VDD A3 n9 VNW pfet_05v0 w=1.095u l=0.5u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__oai33_2')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,15.12,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76),(-0.43,4.35),(15.55,4.35),(15.55,1.76),(13.565,1.76),(13.565,1.885),(7.8,1.885),(7.8,1.76)])
R(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.28,2.485,14.32,3.58)])
P(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,0.34),(0.18,1.16),(8.24,1.16),(8.24,1.285),(13.08,1.285),(13.08,1.16),(14.42,1.16),(14.42,0.34),(12.98,0.34),(12.98,0.465),(8.34,0.465),(8.34,0.34)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.12),(0.62,2.01),(0.72,2.01),(0.72,3.8),(1.22,3.8),(1.22,0.12)],
  [(1.74,0.12),(1.74,2.01),(1.84,2.01),(1.84,3.8),(2.34,3.8),(2.34,0.12)],
  [(2.86,0.12),(2.86,2.01),(2.96,2.01),(2.96,3.8),(3.46,3.8),(3.46,1.97),(3.98,1.97),(3.98,3.8),(4.48,3.8),(4.48,2.01),(4.58,2.01),(4.58,0.12),(3.98,0.12),(3.98,1.73),(3.46,1.73),(3.46,0.12)],
  [(5.1,0.12),(5.1,3.8),(5.6,3.8),(5.6,2.01),(5.7,2.01),(5.7,0.12)],
  [(6.22,0.12),(6.22,3.8),(6.72,3.8),(6.72,2.01),(6.82,2.01),(6.82,0.12)],
  [(7.34,0.12),(7.34,2.01),(7.44,2.01),(7.44,3.8),(7.94,3.8),(7.94,0.12)],
  [(8.68,0.12),(8.68,2.01),(8.78,2.01),(8.78,3.8),(9.28,3.8),(9.28,0.12)],
  [(9.8,0.12),(9.8,2.01),(9.9,2.01),(9.9,3.8),(10.4,3.8),(10.4,1.97),(10.92,1.97),(10.92,3.8),(11.42,3.8),(11.42,2.01),(11.52,2.01),(11.52,0.12),(10.92,0.12),(10.92,1.73),(10.4,1.73),(10.4,0.12)],
  [(12.04,0.12),(12.04,3.8),(12.54,3.8),(12.54,2.01),(12.64,2.01),(12.64,0.12)],
  [(13.38,0.12),(13.38,3.8),(13.88,3.8),(13.88,2.01),(13.98,2.01),(13.98,0.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76,15.32,4.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2,15.32,1.76)])
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 1.37, 0.41, 0.22, 0.22, 3, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 0.25, 0.87, 0.22, 0.22, 3, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 8.31, 0.995, 0.22, 0.22, 3, 1, 2.24, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(6.97,0.535,7.19,0.755), (9.43,0.535,9.65,0.755), (11.67,0.535,11.89,0.755), (14.13,0.535,14.35,0.755), (9.99,1.455,10.21,1.675), (11.11,1.455,11.33,1.675), (5.21,1.785,5.43,2.005), (1.98,1.85,2.2,2.07), (3.1,1.85,3.32,2.07), (4.12,1.85,4.34,2.07), (6.32,1.85,6.54,2.07), (7.58,1.85,7.8,2.07), (8.92,1.85,9.14,2.07), (0.875,1.855,1.095,2.075), (12.18,1.915,12.4,2.135), (13.495,1.94,13.715,2.16), (0.35,2.73,0.57,2.95), (14.03,2.73,14.25,2.95), (3.61,2.97,3.83,3.19), (10.55,2.97,10.77,3.19), (0.35,3.2,0.57,3.42), (14.03,3.2,14.25,3.42), (6.97,3.29,7.19,3.51)])
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(2.89,1.8,4.95,2.12)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(2.41,1.325),(2.41,1.77),(1.51,1.77),(1.51,2.15),(2.66,2.15),(2.66,1.555),(5.18,1.555),(5.18,2.15),(5.48,2.15),(5.48,1.325)],
  [(0.28,1.8),(0.28,2.12),(0.825,2.12),(0.825,2.68),(6.06,2.68),(6.06,2.12),(6.6,2.12),(6.6,1.8),(5.72,1.8),(5.72,2.38),(1.145,2.38),(1.145,1.8)],
  [(8.48,1.78),(8.48,2.14),(12.54,2.14),(12.54,1.91),(9.52,1.91),(9.52,1.78)],
  [(6.85,0.99),(6.85,2.825),(6.41,2.825),(6.41,2.92),(2.75,2.92),(2.75,3.24),(6.66,3.24),(6.66,3.055),(7.5,3.055),(7.5,3.24),(11.215,3.24),(11.215,2.92),(7.75,2.92),(7.75,2.825),(7.15,2.825),(7.15,1.22),(13.07,1.22),(13.07,0.99)],
  [(7.44,1.78),(7.44,2.14),(8,2.14),(8,2.68),(13.775,2.68),(13.775,1.91),(13.435,1.91),(13.435,2.37),(8.23,2.37),(8.23,1.78)],
  [(6.38,0.53),(6.38,0.865),(0.18,0.865),(0.18,1.095),(6.61,1.095),(6.61,0.76),(14.42,0.76),(14.42,0.53)],
  [(13.38,1.16),(13.38,1.45),(9.8,1.45),(9.8,1.68),(14.12,1.68),(14.12,2.38),(14.44,2.38),(14.44,1.16)],
  [(0,-0.3),(0,0.3),(1.31,0.3),(1.31,0.635),(1.65,0.635),(1.65,0.3),(3.55,0.3),(3.55,0.635),(3.89,0.635),(3.89,0.3),(5.79,0.3),(5.79,0.635),(6.13,0.635),(6.13,0.3),(15.12,0.3),(15.12,-0.3)],
  [(0.345,2.63),(0.345,3.62),(0,3.62),(0,4.22),(15.12,4.22),(15.12,3.62),(14.255,3.62),(14.255,2.63),(14.025,2.63),(14.025,3.62),(7.25,3.62),(7.25,3.285),(6.91,3.285),(6.91,3.62),(0.575,3.62),(0.575,2.63)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,15.4,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,15.12,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43,15.55,1.76)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A3', (10.36,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B1', (3.64,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B2', (2.52,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B3', (3.64,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (7.28,3.92), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (7.28,0), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('ZN', (7,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A1', (13.72,1.4), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A2', (9.24,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__oai33_2.gds')

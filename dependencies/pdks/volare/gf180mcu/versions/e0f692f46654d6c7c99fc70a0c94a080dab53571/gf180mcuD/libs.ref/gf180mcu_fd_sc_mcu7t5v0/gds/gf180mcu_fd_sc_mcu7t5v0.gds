* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__oai33_4 A1 A2 A3 B1 B2 B3 VDD VNW VSS ZN
XM1 VSS B2 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM2 n1 B3 VSS VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM3 VSS B1 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM4 ZN A1 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM5 ZN A2 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM6 n1 A3 ZN VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM7 n2 B2 n3 VNW pfet_05v0 w=1.095u l=0.5u
XM8 VDD B3 n2 VNW pfet_05v0 w=1.095u l=0.5u
XM9 n4 B3 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM10 n3 B2 n4 VNW pfet_05v0 w=1.095u l=0.5u
XM11 n5 B2 n3 VNW pfet_05v0 w=1.095u l=0.5u
XM12 VDD B3 n5 VNW pfet_05v0 w=1.095u l=0.5u
XM13 n6 B3 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM14 n7 B2 n6 VNW pfet_05v0 w=1.095u l=0.5u
XM15 ZN B1 n7 VNW pfet_05v0 w=1.095u l=0.5u
XM16 n3 B1 ZN VNW pfet_05v0 w=1.095u l=0.5u m=3
XM17 ZN A1 n8 VNW pfet_05v0 w=1.095u l=0.5u m=3
XM18 n9 A1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM19 n10 A2 n9 VNW pfet_05v0 w=1.095u l=0.5u
XM20 VDD A3 n10 VNW pfet_05v0 w=1.095u l=0.5u
XM21 n11 A3 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM22 n8 A2 n11 VNW pfet_05v0 w=1.095u l=0.5u
XM23 n12 A2 n8 VNW pfet_05v0 w=1.095u l=0.5u
XM24 VDD A3 n12 VNW pfet_05v0 w=1.095u l=0.5u
XM25 n13 A3 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM26 n8 A2 n13 VNW pfet_05v0 w=1.095u l=0.5u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__oai33_4')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,28.56,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76),(-0.43,4.35),(28.99,4.35),(28.99,1.76),(27.235,1.76),(27.235,1.885),(13.55,1.885),(13.55,1.76)])
R(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.23,2.485,13.88,3.58), (14.24,2.485,28.06,3.58)])
P(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,0.34),(0.18,1.16),(14.08,1.16),(14.08,1.285),(26.82,1.285),(26.82,1.16),(28.16,1.16),(28.16,0.34),(26.72,0.34),(26.72,0.465),(14.04,0.465),(14.04,0.34)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.12),(0.62,2.01),(0.72,2.01),(0.72,3.8),(1.22,3.8),(1.22,0.12)],
  [(1.74,0.12),(1.74,2.01),(1.84,2.01),(1.84,3.8),(2.34,3.8),(2.34,1.97),(2.86,1.97),(2.86,3.8),(3.36,3.8),(3.36,2.01),(3.46,2.01),(3.46,0.12),(2.86,0.12),(2.86,1.74),(2.34,1.74),(2.34,0.12)],
  [(3.98,0.12),(3.98,2.01),(4.08,2.01),(4.08,3.8),(4.58,3.8),(4.58,1.97),(5.1,1.97),(5.1,3.8),(5.6,3.8),(5.6,2.01),(5.7,2.01),(5.7,0.12),(5.1,0.12),(5.1,1.74),(4.58,1.74),(4.58,0.12)],
  [(6.22,0.12),(6.22,2.01),(6.32,2.01),(6.32,3.8),(6.82,3.8),(6.82,1.97),(7.34,1.97),(7.34,3.8),(7.84,3.8),(7.84,2.01),(7.94,2.01),(7.94,0.12),(7.34,0.12),(7.34,1.74),(6.82,1.74),(6.82,0.12)],
  [(8.46,0.12),(8.46,3.8),(8.96,3.8),(8.96,2.01),(9.06,2.01),(9.06,0.12)],
  [(9.58,0.12),(9.58,2.01),(9.68,2.01),(9.68,3.8),(10.18,3.8),(10.18,2.01),(10.7,2.01),(10.7,3.8),(11.2,3.8),(11.2,2.01),(11.92,2.01),(11.92,3.8),(12.42,3.8),(12.42,2.01),(12.94,2.01),(12.94,3.8),(13.44,3.8),(13.44,2.01),(13.54,2.01),(13.54,0.12),(12.94,0.12),(12.94,1.74),(12.42,1.74),(12.42,0.12),(11.82,0.12),(11.82,1.74),(11.3,1.74),(11.3,0.12),(10.7,0.12),(10.7,1.74),(10.18,1.74),(10.18,0.12)],
  [(14.58,0.12),(14.58,2.01),(14.68,2.01),(14.68,3.8),(15.18,3.8),(15.18,2.01),(15.7,2.01),(15.7,3.8),(16.2,3.8),(16.2,2.01),(16.92,2.01),(16.92,3.8),(17.42,3.8),(17.42,2.01),(17.94,2.01),(17.94,3.8),(18.44,3.8),(18.44,2.01),(18.54,2.01),(18.54,0.12),(17.94,0.12),(17.94,1.74),(17.42,1.74),(17.42,0.12),(16.82,0.12),(16.82,1.74),(16.3,1.74),(16.3,0.12),(15.7,0.12),(15.7,1.74),(15.18,1.74),(15.18,0.12)],
  [(19.06,0.12),(19.06,2.01),(19.16,2.01),(19.16,3.8),(19.66,3.8),(19.66,0.12)],
  [(20.18,0.12),(20.18,2.01),(20.28,2.01),(20.28,3.8),(20.78,3.8),(20.78,1.97),(21.3,1.97),(21.3,3.8),(21.8,3.8),(21.8,2.01),(21.9,2.01),(21.9,0.12),(21.3,0.12),(21.3,1.74),(20.78,1.74),(20.78,0.12)],
  [(22.42,0.12),(22.42,2.01),(22.52,2.01),(22.52,3.8),(23.02,3.8),(23.02,1.97),(23.54,1.97),(23.54,3.8),(24.04,3.8),(24.04,2.01),(24.14,2.01),(24.14,0.12),(23.54,0.12),(23.54,1.74),(23.02,1.74),(23.02,0.12)],
  [(24.66,0.12),(24.66,2.01),(24.76,2.01),(24.76,3.8),(25.26,3.8),(25.26,1.97),(25.78,1.97),(25.78,3.8),(26.28,3.8),(26.28,2.01),(26.38,2.01),(26.38,0.12),(25.78,0.12),(25.78,1.74),(25.26,1.74),(25.26,0.12)],
  [(27.12,0.12),(27.12,3.8),(27.62,3.8),(27.62,2.01),(27.72,2.01),(27.72,0.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76,28.76,4.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2,28.76,1.76)])
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 1.37, 0.41, 0.22, 0.22, 6, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 16.45, 0.535, 0.22, 0.22, 5, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 0.25, 0.87, 0.22, 0.22, 6, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 15.33, 0.995, 0.22, 0.22, 6, 1, 2.24, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(13.74,0.535,13.96,0.755), (27.87,0.535,28.09,0.755), (0.825,1.69,1.045,1.91), (1.98,1.85,2.2,2.07), (3,1.85,3.22,2.07), (6.46,1.85,6.68,2.07), (7.48,1.85,7.7,2.07), (8.6,1.85,8.82,2.07), (9.82,1.85,10.04,2.07), (10.84,1.85,11.06,2.07), (12.06,1.85,12.28,2.07), (13.045,1.85,13.265,2.07), (14.82,1.85,15.04,2.07), (15.84,1.85,16.06,2.07), (17.06,1.85,17.28,2.07), (18.08,1.85,18.3,2.07), (19.3,1.85,19.52,2.07), (20.42,1.85,20.64,2.07), (21.44,1.85,21.66,2.07), (24.9,1.85,25.12,2.07), (25.92,1.85,26.14,2.07), (27.26,1.85,27.48,2.07), (4.22,1.94,4.44,2.16), (5.24,1.94,5.46,2.16), (22.66,1.94,22.88,2.16), (23.68,1.94,23.9,2.16), (10.33,2.555,10.55,2.775), (12.57,2.555,12.79,2.775), (15.33,2.555,15.55,2.775), (17.57,2.555,17.79,2.775), (0.3,2.63,0.52,2.85), (27.77,2.63,27.99,2.85), (4.73,3.095,4.95,3.315), (11.45,3.095,11.67,3.315), (13.59,3.095,13.81,3.315), (14.31,3.095,14.53,3.315), (16.45,3.095,16.67,3.315), (23.17,3.095,23.39,3.315), (0.3,3.1,0.52,3.32), (27.77,3.1,27.99,3.32), (2.49,3.29,2.71,3.51), (6.97,3.29,7.19,3.51), (20.93,3.29,21.15,3.51), (25.41,3.29,25.63,3.51)])
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(9.58,1.8,13.34,2.12), (14.58,1.8,18.44,2.12)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(3.59,1.335),(3.59,1.8),(1.74,1.8),(1.74,2.12),(3.82,2.12),(3.82,1.565),(6.22,1.565),(6.22,2.12),(8.31,2.12),(8.31,1.8),(6.45,1.8),(6.45,1.335)],
  [(0.775,1.53),(0.775,2.595),(3.52,2.595),(3.52,2.7),(6.16,2.7),(6.16,2.595),(8.84,2.595),(8.84,1.76),(8.58,1.76),(8.58,2.36),(5.52,2.36),(5.52,1.92),(4.16,1.92),(4.16,2.36),(1.095,2.36),(1.095,1.53)],
  [(0.295,2.53),(0.295,3.38),(0.525,3.38),(0.525,3.055),(3.02,3.055),(3.02,3.32),(6.66,3.32),(6.66,3.055),(7.5,3.055),(7.5,3.32),(13.87,3.32),(13.87,3.09),(7.73,3.09),(7.73,2.825),(6.41,2.825),(6.41,3.09),(3.27,3.09),(3.27,2.825),(0.525,2.825),(0.525,2.53)],
  [(13.57,0.99),(13.57,2.36),(9.58,2.36),(9.58,2.795),(17.89,2.795),(17.89,2.36),(13.87,2.36),(13.87,1.22),(26.82,1.22),(26.82,0.99)],
  [(21.685,1.45),(21.685,1.8),(20.18,1.8),(20.18,2.12),(21.915,2.12),(21.915,1.68),(24.545,1.68),(24.545,2.12),(26.835,2.12),(26.835,1.8),(24.775,1.8),(24.775,1.45)],
  [(19.29,1.76),(19.29,2.59),(21.955,2.59),(21.955,2.71),(24.605,2.71),(24.605,2.59),(27.49,2.59),(27.49,1.76),(27.25,1.76),(27.25,2.36),(23.96,2.36),(23.96,1.92),(22.6,1.92),(22.6,2.36),(19.53,2.36),(19.53,1.76)],
  [(27.765,2.53),(27.765,2.825),(24.855,2.825),(24.855,3.09),(21.705,3.09),(21.705,2.825),(20.11,2.825),(20.11,3.09),(14.24,3.09),(14.24,3.32),(20.355,3.32),(20.355,3.055),(21.46,3.055),(21.46,3.32),(25.1,3.32),(25.1,3.055),(27.765,3.055),(27.765,3.38),(27.995,3.38),(27.995,2.53)],
  [(13.1,0.53),(13.1,0.865),(0.18,0.865),(0.18,1.095),(13.33,1.095),(13.33,0.76),(28.16,0.76),(28.16,0.53)],
  [(0,-0.3),(0,0.3),(1.31,0.3),(1.31,0.635),(1.65,0.635),(1.65,0.3),(3.55,0.3),(3.55,0.635),(3.89,0.635),(3.89,0.3),(5.79,0.3),(5.79,0.635),(6.13,0.635),(6.13,0.3),(8.03,0.3),(8.03,0.635),(8.37,0.635),(8.37,0.3),(10.27,0.3),(10.27,0.635),(10.61,0.635),(10.61,0.3),(12.51,0.3),(12.51,0.635),(12.85,0.635),(12.85,0.3),(28.56,0.3),(28.56,-0.3)],
  [(2.43,3.285),(2.43,3.62),(0,3.62),(0,4.22),(28.56,4.22),(28.56,3.62),(25.69,3.62),(25.69,3.285),(25.35,3.285),(25.35,3.62),(21.21,3.62),(21.21,3.285),(20.87,3.285),(20.87,3.62),(7.25,3.62),(7.25,3.285),(6.91,3.285),(6.91,3.62),(2.77,3.62),(2.77,3.285)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,28.84,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,28.56,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43,28.99,1.76)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A3', (24.92,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B1', (11.48,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B2', (4.76,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B3', (6.44,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (14.28,3.92), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (14.28,0), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('ZN', (16.52,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A1', (16.52,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A2', (23.24,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__oai33_4.gds')

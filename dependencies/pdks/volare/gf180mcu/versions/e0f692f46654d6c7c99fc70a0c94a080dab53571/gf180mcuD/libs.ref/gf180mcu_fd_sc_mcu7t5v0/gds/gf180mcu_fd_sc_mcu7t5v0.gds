* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__oai222_2 A1 A2 B1 B2 C1 C2 VDD VNW VSS ZN
XM1 n1 C1 VSS VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM2 VSS C2 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM3 n1 B1 n2 VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM4 n2 B2 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM5 ZN A1 n2 VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM6 n2 A2 ZN VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM7 n3 C1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM8 VDD C2 n3 VNW pfet_05v0 w=1.095u l=0.5u
XM9 n4 C2 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM10 ZN C1 n4 VNW pfet_05v0 w=1.095u l=0.5u
XM11 n5 B1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM12 VDD B2 n5 VNW pfet_05v0 w=1.095u l=0.5u
XM13 n6 B2 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM14 ZN B1 n6 VNW pfet_05v0 w=1.095u l=0.5u
XM15 n7 A1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM16 VDD A2 n7 VNW pfet_05v0 w=1.095u l=0.5u
XM17 n8 A2 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM18 ZN A1 n8 VNW pfet_05v0 w=1.095u l=0.5u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__oai222_2')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,15.12,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76),(-0.43,4.35),(15.55,4.35),(15.55,1.76),(13.995,1.76),(13.995,1.885),(4.94,1.885),(4.94,1.76)])
R(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,0.34,5.02,1.16), (0.28,2.485,14.82,3.58)])
P(gf180mcu_fd_sc_mcu7t5v0_, comp, [(13.48,0.34),(13.48,0.465),(5.38,0.465),(5.38,1.285),(13.58,1.285),(13.58,1.16),(14.92,1.16),(14.92,0.34)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.12),(0.62,2.01),(0.72,2.01),(0.72,3.8),(1.22,3.8),(1.22,0.12)],
  [(1.74,0.12),(1.74,2.01),(1.84,2.01),(1.84,3.8),(2.34,3.8),(2.34,1.97),(2.86,1.97),(2.86,3.8),(3.36,3.8),(3.36,2.01),(3.46,2.01),(3.46,0.12),(2.86,0.12),(2.86,1.74),(2.34,1.74),(2.34,0.12)],
  [(3.98,0.12),(3.98,2.01),(4.08,2.01),(4.08,3.8),(4.58,3.8),(4.58,0.12)],
  [(5.82,0.12),(5.82,2.01),(5.92,2.01),(5.92,3.8),(6.42,3.8),(6.42,0.12)],
  [(6.94,0.12),(6.94,2.01),(7.04,2.01),(7.04,3.8),(7.54,3.8),(7.54,1.97),(8.06,1.97),(8.06,3.8),(8.56,3.8),(8.56,2.01),(8.66,2.01),(8.66,0.12),(8.06,0.12),(8.06,1.74),(7.54,1.74),(7.54,0.12)],
  [(9.18,0.12),(9.18,3.8),(9.68,3.8),(9.68,2.01),(9.78,2.01),(9.78,0.12)],
  [(10.3,0.12),(10.3,2.01),(10.4,2.01),(10.4,3.8),(10.9,3.8),(10.9,0.12)],
  [(11.42,0.12),(11.42,2.01),(11.52,2.01),(11.52,3.8),(12.02,3.8),(12.02,1.97),(12.54,1.97),(12.54,3.8),(13.04,3.8),(13.04,2.01),(13.14,2.01),(13.14,0.12),(12.54,0.12),(12.54,1.74),(12.02,1.74),(12.02,0.12)],
  [(13.88,0.12),(13.88,3.8),(14.38,3.8),(14.38,2.01),(14.48,2.01),(14.48,0.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76,15.32,4.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2,15.32,1.76)])
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 5.45, 0.535, 0.22, 0.22, 4, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 6.57, 0.995, 0.22, 0.22, 4, 1, 2.24, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(2.49,0.41,2.71,0.63), (4.73,0.41,4.95,0.63), (14.63,0.535,14.85,0.755), (0.25,0.565,0.47,0.785), (1.37,0.87,1.59,1.09), (3.61,0.87,3.83,1.09), (0.725,1.6,0.945,1.82), (4.1,1.6,4.32,1.82), (10.58,1.745,10.8,1.965), (1.98,1.85,2.2,2.07), (3,1.85,3.22,2.07), (6.06,1.85,6.28,2.07), (7.18,1.85,7.4,2.07), (8.2,1.85,8.42,2.07), (9.33,1.85,9.55,2.07), (11.66,1.85,11.88,2.07), (12.68,1.85,12.9,2.07), (14.035,1.85,14.255,2.07), (0.35,2.83,0.57,3.05), (4.73,2.97,4.95,3.19), (5.55,2.97,5.77,3.19), (9.93,2.97,10.15,3.19), (14.53,2.97,14.75,3.19), (2.49,3.29,2.71,3.51), (7.69,3.29,7.91,3.51), (12.17,3.29,12.39,3.51)])
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(5.39,0.53,14.92,0.76), (1.53,1.8,3.46,2.12), (6.77,1.8,8.87,2.12), (11.29,1.8,13.39,2.12)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(0.66,1.335),(0.66,2.19),(1.02,2.19),(1.02,1.57),(4.01,1.57),(4.01,2.12),(5.015,2.12),(5.015,1.8),(4.38,1.8),(4.38,1.335)],
  [(1.31,0.865),(1.31,1.095),(4.88,1.095),(4.88,1.22),(9.09,1.22),(9.09,0.99),(5.13,0.99),(5.13,0.865)],
  [(9.1,1.77),(9.1,2.365),(6.3,2.365),(6.3,1.79),(6.04,1.79),(6.04,2.365),(5.07,2.365),(5.07,2.69),(6.74,2.69),(6.74,2.595),(9.38,2.595),(9.38,2.15),(9.68,2.15),(9.68,1.77)],
  [(14.005,1.16),(14.005,2.365),(11.06,2.365),(11.06,1.645),(10.525,1.645),(10.525,2.595),(13.285,2.595),(13.285,2.69),(14.46,2.69),(14.46,1.16)],
  [(9.93,0.99),(9.93,2.825),(7.09,2.825),(7.09,2.92),(3.42,2.92),(3.42,2.825),(0.28,2.825),(0.28,3.055),(3.125,3.055),(3.125,3.24),(7.34,3.24),(7.34,3.055),(8.445,3.055),(8.445,3.24),(11.775,3.24),(11.775,3.055),(12.72,3.055),(12.72,3.24),(14.82,3.24),(14.82,2.92),(12.95,2.92),(12.95,2.825),(10.16,2.825),(10.16,1.22),(13.57,1.22),(13.57,0.99)],
  [(0,-0.3),(0,0.3),(0.245,0.3),(0.245,0.845),(0.475,0.845),(0.475,0.3),(2.43,0.3),(2.43,0.635),(2.77,0.635),(2.77,0.3),(4.67,0.3),(4.67,0.635),(5.01,0.635),(5.01,0.3),(15.12,0.3),(15.12,-0.3)],
  [(2.43,3.285),(2.43,3.62),(0,3.62),(0,4.22),(15.12,4.22),(15.12,3.62),(12.45,3.62),(12.45,3.285),(12.11,3.285),(12.11,3.62),(7.97,3.62),(7.97,3.285),(7.63,3.285),(7.63,3.62),(2.77,3.62),(2.77,3.285)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,15.4,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,15.12,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43,15.55,1.76)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B1', (6.44,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B2', (7.56,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('C1', (4.2,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('C2', (2.52,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (7.56,3.92), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (7.56,0), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('ZN', (8.68,3.08), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A1', (13.72,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A2', (12.6,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__oai222_2.gds')

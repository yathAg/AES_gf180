* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__oai22_4 A1 A2 B1 B2 VDD VNW VSS ZN
XM1 VSS B2 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM2 n1 B1 VSS VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM3 ZN A2 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM4 n1 A1 ZN VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM5 n2 B2 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM6 ZN B1 n2 VNW pfet_05v0 w=1.095u l=0.5u
XM7 n3 B1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM8 VDD B2 n3 VNW pfet_05v0 w=1.095u l=0.5u
XM9 n4 B2 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM10 ZN B1 n4 VNW pfet_05v0 w=1.095u l=0.5u
XM11 n5 B1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM12 VDD B2 n5 VNW pfet_05v0 w=1.095u l=0.5u
XM13 n6 A2 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM14 ZN A1 n6 VNW pfet_05v0 w=1.095u l=0.5u
XM15 n7 A1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM16 VDD A2 n7 VNW pfet_05v0 w=1.095u l=0.5u
XM17 n8 A2 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM18 ZN A1 n8 VNW pfet_05v0 w=1.095u l=0.5u
XM19 n9 A1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM20 VDD A2 n9 VNW pfet_05v0 w=1.095u l=0.5u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__oai22_4')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,19.6,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76),(-0.43,4.35),(20.03,4.35),(20.03,1.76),(17.95,1.76),(17.95,1.885),(10.09,1.885),(10.09,1.76)])
R(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.28,2.485,18.8,3.58)])
P(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,0.34),(0.18,1.16),(10.48,1.16),(10.48,1.285),(17.56,1.285),(17.56,1.16),(18.9,1.16),(18.9,0.34),(17.46,0.34),(17.46,0.465),(10.58,0.465),(10.58,0.34)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.12),(0.62,2.005),(0.72,2.005),(0.72,3.8),(1.22,3.8),(1.22,0.12)],
  [(1.74,0.12),(1.74,2.005),(1.84,2.005),(1.84,3.8),(2.34,3.8),(2.34,2.005),(2.86,2.005),(2.86,3.8),(3.36,3.8),(3.36,2.005),(3.46,2.005),(3.46,0.12),(2.86,0.12),(2.86,1.72),(2.34,1.72),(2.34,0.12)],
  [(3.98,0.12),(3.98,2.005),(4.08,2.005),(4.08,3.8),(4.58,3.8),(4.58,2.005),(5.1,2.005),(5.1,3.8),(5.6,3.8),(5.6,2.005),(5.7,2.005),(5.7,0.12),(5.1,0.12),(5.1,1.72),(4.58,1.72),(4.58,0.12)],
  [(6.22,0.12),(6.22,2.005),(6.32,2.005),(6.32,3.8),(6.82,3.8),(6.82,2.005),(7.34,2.005),(7.34,3.8),(7.84,3.8),(7.84,2.005),(7.94,2.005),(7.94,0.12),(7.34,0.12),(7.34,1.72),(6.82,1.72),(6.82,0.12)],
  [(8.46,0.12),(8.46,3.8),(8.96,3.8),(8.96,2.005),(9.06,2.005),(9.06,0.12)],
  [(9.58,0.12),(9.58,2.005),(9.68,2.005),(9.68,3.8),(10.18,3.8),(10.18,0.12)],
  [(10.92,0.12),(10.92,2.005),(11.02,2.005),(11.02,3.8),(11.52,3.8),(11.52,2.005),(12.04,2.005),(12.04,3.8),(12.54,3.8),(12.54,2.005),(12.64,2.005),(12.64,0.12),(12.04,0.12),(12.04,1.72),(11.52,1.72),(11.52,0.12)],
  [(13.16,0.12),(13.16,2.005),(13.26,2.005),(13.26,3.8),(13.76,3.8),(13.76,2.005),(14.28,2.005),(14.28,3.8),(14.78,3.8),(14.78,2.005),(14.88,2.005),(14.88,0.12),(14.28,0.12),(14.28,1.72),(13.76,1.72),(13.76,0.12)],
  [(15.4,0.12),(15.4,2.005),(15.5,2.005),(15.5,3.8),(16,3.8),(16,2.005),(16.52,2.005),(16.52,3.8),(17.02,3.8),(17.02,2.005),(17.12,2.005),(17.12,0.12),(16.52,0.12),(16.52,1.72),(16,1.72),(16,0.12)],
  [(17.86,0.12),(17.86,3.8),(18.36,3.8),(18.36,2.005),(18.46,2.005),(18.46,0.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76,19.8,4.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2,19.8,1.76)])
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 1.37, 0.49, 0.22, 0.22, 4, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 11.67, 0.535, 0.22, 0.22, 3, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 0.25, 0.555, 0.22, 0.22, 4, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 10.55, 0.995, 0.22, 0.22, 4, 1, 2.24, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(9.21,0.535,9.43,0.755), (18.61,0.535,18.83,0.755), (6.41,1.41,6.63,1.63), (7.53,1.41,7.75,1.63), (15.59,1.455,15.81,1.675), (16.71,1.455,16.93,1.675), (0.895,1.685,1.115,1.905), (1.98,1.84,2.2,2.06), (3,1.84,3.22,2.06), (11.16,1.84,11.38,2.06), (12.18,1.84,12.4,2.06), (9.81,1.85,10.03,2.07), (4.22,1.87,4.44,2.09), (5.24,1.87,5.46,2.09), (8.57,1.87,8.79,2.09), (13.4,1.915,13.62,2.135), (14.42,1.915,14.64,2.135), (18,1.915,18.22,2.135), (6.97,2.63,7.19,2.85), (16.15,2.63,16.37,2.85), (0.35,2.69,0.57,2.91), (18.51,2.69,18.73,2.91), (2.49,2.97,2.71,3.19), (11.67,2.97,11.89,3.19), (6.97,3.1,7.19,3.32), (16.15,3.1,16.37,3.32), (0.35,3.16,0.57,3.38), (18.51,3.16,18.73,3.38), (4.73,3.26,4.95,3.48), (9.21,3.26,9.43,3.48), (13.91,3.26,14.13,3.48)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(3.11,1.405),(3.11,1.785),(1.53,1.785),(1.53,2.12),(3.36,2.12),(3.36,1.635),(7.94,1.635),(7.94,1.405)],
  [(0.825,1.585),(0.825,2.68),(3.94,2.68),(3.94,2.095),(8.85,2.095),(8.85,1.865),(3.69,1.865),(3.69,2.36),(1.145,2.36),(1.145,1.585)],
  [(12.29,1.45),(12.29,1.785),(10.73,1.785),(10.73,2.12),(12.54,2.12),(12.54,1.68),(17.12,1.68),(17.12,1.45)],
  [(9.08,0.99),(9.08,2.795),(7.25,2.795),(7.25,2.57),(6.91,2.57),(6.91,2.795),(4.17,2.795),(4.17,2.92),(1.73,2.92),(1.73,3.24),(4.42,3.24),(4.42,3.025),(5.255,3.025),(5.255,3.38),(8.905,3.38),(8.905,3.025),(9.74,3.025),(9.74,3.24),(13.605,3.24),(13.605,3.025),(14.44,3.025),(14.44,3.38),(16.375,3.38),(16.375,2.485),(16.145,2.485),(16.145,2.92),(14.69,2.92),(14.69,2.795),(13.355,2.795),(13.355,2.92),(9.99,2.92),(9.99,2.795),(9.38,2.795),(9.38,1.22),(17.56,1.22),(17.56,0.99)],
  [(9.61,1.8),(9.61,2.12),(10.2,2.12),(10.2,2.68),(13.125,2.68),(13.125,2.14),(18.46,2.14),(18.46,1.91),(12.875,1.91),(12.875,2.36),(10.5,2.36),(10.5,1.8)],
  [(8.61,0.53),(8.61,0.945),(7.25,0.945),(7.25,0.55),(6.91,0.55),(6.91,0.945),(5.01,0.945),(5.01,0.55),(4.67,0.55),(4.67,0.945),(2.77,0.945),(2.77,0.55),(2.43,0.55),(2.43,0.945),(0.53,0.945),(0.53,0.55),(0.19,0.55),(0.19,1.175),(8.84,1.175),(8.84,0.76),(18.9,0.76),(18.9,0.53)],
  [(0,-0.3),(0,0.3),(1.31,0.3),(1.31,0.715),(1.65,0.715),(1.65,0.3),(3.55,0.3),(3.55,0.715),(3.89,0.715),(3.89,0.3),(5.79,0.3),(5.79,0.715),(6.13,0.715),(6.13,0.3),(8.03,0.3),(8.03,0.715),(8.37,0.715),(8.37,0.3),(19.6,0.3),(19.6,-0.3)],
  [(0.345,2.59),(0.345,3.62),(0,3.62),(0,4.22),(19.6,4.22),(19.6,3.62),(18.735,3.62),(18.735,2.59),(18.505,2.59),(18.505,3.62),(14.19,3.62),(14.19,3.255),(13.85,3.255),(13.85,3.62),(9.49,3.62),(9.49,3.255),(9.15,3.255),(9.15,3.62),(5.01,3.62),(5.01,3.255),(4.67,3.255),(4.67,3.62),(0.575,3.62),(0.575,2.59)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,19.88,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,19.6,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43,20.03,1.76)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B1', (3.08,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (9.52,3.92), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (9.52,0), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('ZN', (10.36,3.08), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A1', (12.04,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A2', (12.6,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B2', (3.64,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__oai22_4.gds')

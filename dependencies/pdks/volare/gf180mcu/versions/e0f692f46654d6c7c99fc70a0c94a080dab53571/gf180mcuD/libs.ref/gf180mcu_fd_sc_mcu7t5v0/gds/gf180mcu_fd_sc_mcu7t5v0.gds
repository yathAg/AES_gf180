* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__oai211_2 A1 A2 B C VDD VNW VSS ZN
XM1 ZN A2 n1 VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM2 n1 A1 ZN VSUBS nfet_05v0 w=0.82u l=0.6u m=2
XM3 n2 B n1 VSUBS nfet_05v0 w=0.82u l=0.6u
XM4 VSS C n2 VSUBS nfet_05v0 w=0.82u l=0.6u
XM5 n3 C VSS VSUBS nfet_05v0 w=0.82u l=0.6u
XM6 n1 B n3 VSUBS nfet_05v0 w=0.82u l=0.6u
XM7 n4 A2 VDD VNW pfet_05v0 w=1.095u l=0.5u
XM8 ZN A1 n4 VNW pfet_05v0 w=1.095u l=0.5u
XM9 n5 A1 ZN VNW pfet_05v0 w=1.095u l=0.5u
XM10 VDD A2 n5 VNW pfet_05v0 w=1.095u l=0.5u
XM11 ZN B VDD VNW pfet_05v0 w=0.985u l=0.5u m=2
XM12 VDD C ZN VNW pfet_05v0 w=0.985u l=0.5u m=2
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__oai211_2')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,10.08,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76),(-0.43,4.35),(10.51,4.35),(10.51,1.76),(4.615,1.76),(4.615,1.885),(1.075,1.885),(1.075,1.76)])
P(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,0.34),(0.18,1.16),(1.52,1.16),(1.52,1.285),(4.12,1.285),(4.12,1.16),(9.645,1.16),(9.645,0.34),(4.02,0.34),(4.02,0.465),(1.66,0.465),(1.66,0.34)],
  [(0.28,2.485),(0.28,3.58),(9.645,3.58),(9.645,2.595),(5.32,2.595),(5.32,2.485)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.12),(0.62,2.005),(0.72,2.005),(0.72,3.8),(1.22,3.8),(1.22,0.12)],
  [(1.96,0.12),(1.96,2.005),(2.06,2.005),(2.06,3.8),(2.56,3.8),(2.56,2.005),(3.08,2.005),(3.08,3.8),(3.58,3.8),(3.58,2.005),(3.68,2.005),(3.68,0.12),(3.08,0.12),(3.08,1.74),(2.56,1.74),(2.56,0.12)],
  [(4.42,0.12),(4.42,3.8),(4.92,3.8),(4.92,2.005),(5.02,2.005),(5.02,0.12)],
  [(5.545,0.12),(5.545,2.005),(5.645,2.005),(5.645,3.8),(6.145,3.8),(6.145,0.12)],
  [(6.565,0.12),(6.565,2.005),(6.665,2.005),(6.665,3.8),(7.165,3.8),(7.165,2.005),(7.685,2.005),(7.685,3.8),(8.185,3.8),(8.185,2.005),(8.285,2.005),(8.285,0.12),(7.685,0.12),(7.685,1.74),(7.165,1.74),(7.165,0.12)],
  [(8.605,0.12),(8.605,2.005),(8.705,2.005),(8.705,3.8),(9.205,3.8),(9.205,0.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76,10.28,4.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2,10.28,1.76)])
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(7.315,0.41,7.535,0.63), (0.25,0.535,0.47,0.755), (2.71,0.535,2.93,0.755), (5.175,0.535,5.395,0.755), (9.355,0.535,9.575,0.755), (1.59,0.995,1.81,1.215), (3.83,0.995,4.05,1.215), (0.875,1.61,1.095,1.83), (5.77,1.745,5.99,1.965), (8.885,1.745,9.105,1.965), (2.2,1.85,2.42,2.07), (3.22,1.85,3.44,2.07), (4.58,1.85,4.8,2.07), (6.805,1.85,7.025,2.07), (7.825,1.85,8.045,2.07), (0.35,2.695,0.57,2.915), (9.355,2.695,9.575,2.915), (2.71,2.995,2.93,3.215), (6.295,2.995,6.515,3.215), (8.335,2.995,8.555,3.215), (0.35,3.165,0.57,3.385), (9.355,3.165,9.575,3.385), (5.175,3.21,5.395,3.43), (7.315,3.21,7.535,3.43)])
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(1.56,1.79,3.87,2.12), (6.28,1.8,8.32,2.14)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(0.825,1.16),(0.825,2.68),(4.38,2.68),(4.38,2.12),(4.9,2.12),(4.9,1.79),(4.12,1.79),(4.12,2.35),(1.145,2.35),(1.145,1.16)],
  [(1.53,0.99),(1.53,1.56),(5.15,1.56),(5.15,2.37),(4.63,2.37),(4.63,2.92),(2.13,2.92),(2.13,3.28),(4.86,3.28),(4.86,2.68),(6.29,2.68),(6.29,3.275),(6.52,3.275),(6.52,2.68),(8.33,2.68),(8.33,3.275),(8.56,3.275),(8.56,2.38),(5.48,2.38),(5.48,1.22),(4.11,1.22),(4.11,0.99),(3.77,0.99),(3.77,1.22),(1.87,1.22),(1.87,0.99)],
  [(5.72,1.19),(5.72,2.15),(6.04,2.15),(6.04,1.555),(8.865,1.555),(8.865,2.19),(9.42,2.19),(9.42,1.19),(8.38,1.19),(8.38,1.325),(6.485,1.325),(6.485,1.19)],
  [(0.18,0.53),(0.18,0.76),(6.735,0.76),(6.735,1.095),(8.08,1.095),(8.08,0.76),(9.645,0.76),(9.645,0.53),(7.85,0.53),(7.85,0.865),(6.965,0.865),(6.965,0.53)],
  [(0,-0.3),(0,0.3),(7.255,0.3),(7.255,0.635),(7.595,0.635),(7.595,0.3),(10.08,0.3),(10.08,-0.3)],
  [(0.345,2.485),(0.345,3.62),(0,3.62),(0,4.22),(10.08,4.22),(10.08,3.62),(9.58,3.62),(9.58,2.595),(9.35,2.595),(9.35,3.62),(7.595,3.62),(7.595,3.205),(7.255,3.205),(7.255,3.62),(5.455,3.62),(5.455,3.205),(5.115,3.205),(5.115,3.62),(0.575,3.62),(0.575,2.485)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,10.36,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,10.08,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43,10.51,1.76)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A2', (3.08,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('ZN', (5.32,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A1', (2.52,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B', (8.68,1.4), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('C', (7.56,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (4.76,3.92), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (4.76,0), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__oai211_2.gds')
